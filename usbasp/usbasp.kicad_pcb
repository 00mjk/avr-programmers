# Repository 00mjk/avr-programmers

File README.md:

# Open-source avr programmers
programatory open-source dla układów AVR

W drzewie katalogu:
- bsd, chyba najprostszy programator układów AVR, wykorzystujący port LPT komputera PC,
- dasa, programator układów AVR wykorzystujący port szeregowy RS232,
- usbasp, układ wykorzystujący port USB, chyba najbardziej popularny i rozpowszechniony,
- dasa-3, programator układów AVR wykorzystujący port szeregowy RS232,
- Arduino Uno ISP shield, czyli ... ArduinoISP.

Wszystkie programatory obsługiwane są przez program AVR Dude (avrdude).

_mgr inż. Paweł Sobótka_

## KiCad design usbasp/usbasp.kicad_pcb

File usbasp/README.md:

# USBasp programmer
avr-programmers

Perhaps, most popular programmer at the World. Build with AVR chips and a few others components. Work fine with AVRDude, under Linux, of course. Here we have a schematic sheet of this electronic circuit:

It was made with KiCad, an Open Source EDA Software package. Here, below we have PCB layout:

At the end, have a fun with that project and be patient, because these project need that at all.

I will be forgotten! Original firmware doesn't compile anyway, make print errors and I made some changes into source code, I think it will work!

_MSc. Paweł Sobótka (SQ7EQE)_

Parts:
C1, C2: 22pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3, C5: 100n; C_Rect_L7.0mm_W2.5mm_P5.00mm
C4: 4u7; CP_Radial_D5.0mm_P2.50mm
D1, D2: 3V6; D_DO-35_SOD27_P7.62mm_Horizontal
D3: red; LED_D3.0mm
D4: green; LED_D3.0mm
D5: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: USB_B; USB_Micro-B_Molex_47346-0001
J2: TxD RxD; PinHeader_1x02_P2.54mm_Vertical
J3: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
JP1: supply target; PinHeader_1x02_P2.54mm_Vertical
JP2: slow SCK; PinHeader_1x02_P2.54mm_Vertical
JP3: self programming; PinHeader_1x02_P2.54mm_Vertical
R1: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 2k2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4: 68; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6, R7: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: RESET; SW_PUSH_6mm
U1: ATmega8-16PU; DIP-28_W7.62mm
Y1: 12MHz; Crystal_HC49-U_Vertical

Connections:
+5V: C3.1, C4.1, D5.1 (K), J1.1 (VBUS), JP1.2 (B), R1.1, R2.2, R5.1, R6.1, U1.7 (VCC), U1.20 (AVCC)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, D1.2 (A), D2.2 (A), J1.4 (GND), J1.5 (Shield), J3.4 (GND), J3.6 (GND), J3.8 (GND), J3.10 (GND), JP2.2 (B), SW1.1, U1.8 (GND), U1.22 (AGND)
unnamed: C1.1, U1.9 (PB6/XTAL1), Y1.1
unnamed: C2.1, U1.10 (PB7/XTAL2), Y1.2
unnamed: C5.2, D5.2 (A), JP3.1 (A), R1.2, SW1.2, U1.1 (PC6/~RESET)
unnamed: D1.1 (K), J1.2 (D-), R2.1, R4.2
unnamed: D2.1 (K), J1.3 (D+), R3.2
unnamed: D3.1 (K), U1.23 (PC0)
unnamed: D3.2 (A), R5.2
unnamed: D4.1 (K), U1.24 (PC1)
unnamed: D4.2 (A), R6.2
unnamed: J2.1, R7.1
unnamed: J2.2, U1.2 (PD0)
unnamed: J3.1 (MOSI), U1.17 (PB3)
unnamed: J3.5 (~RST), JP3.2 (B), U1.16 (PB2)
unnamed: J3.7 (SCK), U1.19 (PB5)
unnamed: J3.9 (MISO), U1.18 (PB4)
unnamed: JP2.1 (A), U1.25 (PC2)
unnamed: R3.1, U1.4 (PD2), U1.15 (PB1)
unnamed: R4.1, U1.14 (PB0)
unnamed: R7.2, U1.3 (PD1)
VCCINT: J3.2 (VCC), JP1.1 (A)

Notes on the sheet:
Note: all resistors 0.25W capacitors 100V polarity capacitor 16V Zenner diodes 0.5W

Board: 2 copper layers, 80.0 x 50.0 mm, 26 parts (0 on the bottom side), 22 nets.

## KiCad design dasa-3/dasa-3.kicad_pcb

File dasa-3/README.md:

# Device AVR Serial Adapter
electronics workshop

I present You a DASA-3, Programmer using a RS232 port. Programmed device must be powered from own circuit, not from programmer. What you need, to build this circuit? A few component:

- 3 x resistors 4k7
- 1 x resistor 10k
- 2 x Zener Diode 1N4733A
- 1 x transistor NPN BC546
- 1 x IDC-6 connector
- 1 x IDC-10 connector
- 1 x DB9 male connector

Here we have a 3D view of PCB:

I create project of PCB, all things I done with use of KiCad. Below, is that picture from discussed project. For create all documentation I have used Open Source Software & License used for publish project documentation are Open Source too. I use GNU GPLv3 license, for that. Here we have a PCB layout:

Project files, included Gerber files are inside this folder. I will be very glad if you use it for yourself satisfaction or in yours jobs. Feel free and share them with your friends. 

_mgr inż. Paweł Sobótka (SQ7EQE)_

Parts:
D1, D2: 1N4733A; D_DO-35_SOD27_P7.62mm_Horizontal
D3: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: DB9_Male; DSUB-9_Male_Horizontal_P2.77x2.54mm_EdgePinOffset9.40mm
J2: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
J3: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical
Q1: BC546; TO-92_Inline
R1, R2, R4: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R5: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
GND: D1.2 (A), D2.2 (A), J1.5, J2.4 (GND), J2.6 (GND), J2.8 (GND), J2.10 (GND), J3.6 (GND), Q1.3 (E), R4.1
unnamed: D1.1 (K), J2.1 (MOSI), J3.4 (MOSI), R1.1
unnamed: D2.1 (K), J2.7 (SCK), J3.3 (SCK), R2.1
unnamed: D3.1 (K), Q1.2 (B), R4.2
unnamed: D3.2 (A), R3.1
unnamed: J1.3, R1.2
unnamed: J1.4, R3.2
unnamed: J1.7, R2.2
unnamed: J1.8, J2.9 (MISO), J3.1 (MISO)
unnamed: J2.2 (VCC), J3.2 (VCC), R5.1
unnamed: J2.5 (~RST), J3.5 (~RST), Q1.1 (C), R5.2

Notes on the sheet:
Zener diodes 500mW resistors 0.125W
programmed avr powered form own circuit

Board: 2 copper layers, 31.5 x 63.5 mm, 12 parts (0 on the bottom side), 11 nets.

## KiCad design bsd_programmer/bsd_programmer.kicad_pcb

File bsd_programmer/README.md:

# 'bsd' parallel programmer

Hi! Here you have a KiCad project of classic, a bsd parallel programmer. It is simply, cheap and works with AVRDude.

here we have a schematics sheet

and ... PCB layout

Have a fun with that project!

Parts:
H1: M2.5; MountingHole_2.5mm
J1: DB25_Male; DSUB-25_Male_Horizontal_P2.77x2.54mm_EdgePinOffset9.40mm
J2: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
ACK: J1.10, R5.2
D0: J1.2, R1.2
D1: J1.3, R2.2
D2: J1.4, R3.2
D3: J1.5, R4.2
D5: J1.7, R8.2
D6: J1.8, R7.2
D7: J1.9, R6.2
unnamed: J1.18, J1.19, J1.20, J1.21, J1.22, J1.23, J1.24, J1.25, J2.4 (GND), J2.6 (GND), J2.8 (GND), J2.10 (GND)
unnamed: J2.1 (MOSI), R6.1
unnamed: J2.2 (VCC), R1.1, R2.1, R3.1, R4.1
unnamed: J2.5 (~RST), R8.1
unnamed: J2.7 (SCK), R7.1
unnamed: J2.9 (MISO), R5.1

Notes on the sheet:
AVR "BSD" Programmer
Centronics pinouts

Board: 2 copper layers, 50.3 x 54.6 mm, 12 parts (0 on the bottom side), 14 nets.

Other parts of the board:
H1#2: M2.5; MountingHole_2.5mm

## KiCad design avr_prog_uno_shield/avr_prog_uno_shiled.kicad_pcb

File avr_prog_uno_shield/README.md:

# ArduinoISP programmer shield for Uno

Hi! Here you have an Arduino Uno shield. It was inspired by [arduino.cc](https://www.arduino.cc "Arduino Main") webpage. This is an AVR ISP programmer shield.

Here we have a schemtaic sheet

and here a PCB layout

Have a fun with that project!

Parts:
C1: 10u; CP_Radial_D6.3mm_P2.50mm
D1: HEARTBEAT; LED_D5.0mm
D2: ERROR; LED_D5.0mm
D3: PROGRAMMING; LED_D5.0mm
J1: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
P1: Power; PinHeader_1x08_P2.54mm_Vertical
P2: Analog; PinHeader_1x06_P2.54mm_Vertical
P3: Digital; PinHeader_1x10_P2.54mm_Vertical
P4: Digital; PinHeader_1x08_P2.54mm_Vertical
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
R1, R2, R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
+3V3: P1.4
+5V: J1.2 (VCC), P1.5
/0(Rx): P4.8
/1(Tx): P4.7
/2: P4.6
/3(**): P4.5
/4: P4.4
/5(**): P4.3
/6(**): P4.2
/7: P4.1, R3.1
/8: P3.10, R2.1
/9(**): P3.9, R1.1
/10(**SS): J1.5 (~RST), P3.8
/11(**MOSI): J1.1 (MOSI), P3.7
/12(MISO): J1.9 (MISO), P3.6
/13(SCK): J1.7 (SCK), P3.5
/A0: P2.1
/A1: P2.2
/A2: P2.3
/A3: P2.4
/A4(SDA): P2.5, P3.2
/A5(SCL): P2.6, P3.1
/AREF: P3.3
/IOREF: P1.2
/Reset: C1.1, P1.3
/Vin: P1.8
GND: C1.2, D1.1 (K), D2.1 (K), D3.1 (K), J1.4 (GND), J1.6 (GND), J1.8 (GND), J1.10 (GND), P1.6, P1.7, P3.4
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.

Board: 2 copper layers, 68.6 x 53.3 mm, 16 parts (4 on the bottom side), 15 nets.

## KiCad design dasa/dasa.kicad_pcb

File dasa/README.md:

# Device AVR Serial Adapter (dasa)
electronics workshop

As in title, simple, cheap and easy to build. Programmer using the RS232 port, working with AVRDude. Below 3D view of PCB layout:

To build, you need a few components:

- 3 x resistor 0.125W each 3k3
- 1 x resistor 0.125W 100 Ohm
- 8 diodes 1N4151
- 1 polarized capacitor 10u/16V
- 1 barrel DC connector
- 1 IDC-10 female connector
- 1 DB9 connector
- prototyping laminate or own PCB(make with Gerber files from gerbv/ folder)

Schematic Sheet is also in PDF format, included from drawings/ folder

Programmer works well with AVRDude, under Linux, Windows and MacOS.

Here, we have a PCB Layout view:

Have a fun with that project! Make better AVR's projects.

_mgr inż. Paweł Sobótka (SQ7EQE)_

Board: 2 copper layers, 46.0 x 81.0 mm, 16 parts (0 on the bottom side), 11 nets.

Parts:
C1: 10uF/16V; CP_Radial_D8.0mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8: 1N4151; D_A-405_P12.70mm_Horizontal
J1: DB9_Male; DSUB-9_Male_Horizontal_P2.77x2.54mm_EdgePinOffset9.40mm
J2: AVR-ISP-10; IDC-Header_2x05_P2.54mm_Vertical
J3: +5V; BarrelJack_CUI_PJ-063AH_Horizontal
R1, R2, R3: 3k3; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
/CTS: J1.8, J2.9
/DSR: D5.1, D6.2, J1.6, J2.5, R1.1
/DTR: J1.4, R3.2
/RTS: J1.7, R1.2
/TxD: J1.3, R2.2
unnamed: C1.1, D1.2, D3.2, D5.2, D7.2, R4.1
unnamed: C1.2, D2.1, D4.1, D6.1, D8.1, R4.2
unnamed: D1.1, D2.2, J2.1, R2.1
unnamed: D3.1, D4.2, J2.7, R3.1
unnamed: D7.1, J2.2, J3.1
unnamed: D8.2, J1.5, J2.4, J2.6, J2.8, J2.10, J3.2

## Commit log

2019-07-21 initial commit
    I have add new project, all make with Kicad
2019-07-21 update
    dodałem trochę treści do pliku ...
2019-07-21 update
    after spell check
2019-07-21 update
    add sheet table description
2019-07-21 update
    modified
2019-07-22 update & new content
    I have add new project, dasa-3 programmer & update README.md file
2019-07-23 update & new file
    I have generated picture with 3d view of PCB
    I have draw schematic scheets into PDF file format
2019-08-02 updated image
    I have changed image of 3d view PCB layout
2019-08-16 fix: update project
2019-09-16 new content: ArduinoISP
2019-09-16 update: fix invalid path
2019-09-16 update: new content & update license info
2019-09-16 update: fixed path
2019-09-18 update: new revision
2019-09-18 update: add README file
2019-09-18 update: validate path to picture
2019-09-18 update: fix mistakes
2019-09-18 update: some grammar issues, now correct
2019-09-18 fixed: add missed folder
2019-09-19 update: update folder with new contents
2019-09-20 update: update project files
2019-10-13 update: prepare Gerber files for productions
2019-11-11 update: I have modified PCB design
2021-12-09 update to the latest version

Notices in the files:
dasa/dasa.kicad_pcb:
GNU GPLv3, 2019
